FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://usb-wifi-rt5370.cfg"
